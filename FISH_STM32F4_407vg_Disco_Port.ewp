# IAR project FISH_STM32F4_407vg_Disco_Port.ewp, settings and files
configuration STM32F407vg_Disco_Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VG ST STM32F407VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: ..\FISH_Libs\FISH_RM_COMMON; ..\FISH_Libs\FISH_RM_COMMON_CODE_CORTEX_M
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: FISH_PubRel_WORDSET; FISH_Debug_WORDSET; STM32F4_XRC08_168MHZ
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: FISH_STM32F4_DISCO_Debug_ddmmyyyy_hhmmss.v1.7.2.hex
  ILINK.IlinkOutputFile: FISH_STM32F407_DISCO_Debug_ddmmyyyy_hhmmss.v1.7.2.out
  ILINK.IlinkIcfFile: stm32f407xG.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32F407vg_Disco_PubRel (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 1
  AARM.ADefines: FISH_PubRel_WORDSET; STM32F4_XRC08_168MHZ
  AARM.AUserIncludes: ..\FISH_RM_COMMON; ..\FISH_RM_COMMON_CODE_CORTEX_M
  OBJCOPY.OOCOutputFile: FISH_FORTH_STM32F4_Disco_PUBREL_RM_v1.7.hex
  ILINK.IlinkOutputFile: FISH_FORTH_STM32F4_Disco_PUBREL_RM_v1.7.out
  ILINK.IlinkIcfFile: C:\Users\cwpjr\Dropbox\CWP\FISH IAR\FISH_STM32Fx_Port\stm32f407xG.icf
configuration STM32F407vg_Disco (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F205RC ST STM32F205RC
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  AARM.ADefines: FISH_PubRel_WORDSET; FISH_Debug_WORDSET; UNDEF_VTOR_PATCH; STM32F205RC; STM32F205RC_SRAM128; STM32F205RC_XRC10_118MHZ
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: FISH_STM32F205RC_STM_118mhz_Debug_ddmmyyyy_hhmmss.v1.7.hex
  ILINK.IlinkOutputFile: FISH_STM32F205RC_STM_118mhz_Debug_ddmmyyyy_hhmmss.v1.7.out
  ILINK.IlinkIcfFile: stm32F205RC.icf
  group (top)
    ./: FISH_STM32F4_IAR.s FISH_STM32F4_Peripheral_Register_ADDRS.h ioSTM32F4x7x.h main.c startup_stm32f4xx.s
